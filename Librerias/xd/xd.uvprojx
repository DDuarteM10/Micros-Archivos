# Keil uVision project xd.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F401RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IRAM(0x20000000,0x00018000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: xd
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group Source Group 1
    ../ADC/: ADC.cpp
    ../Delay/: Delay.cpp
    ../GLCD/: GLCD.cpp GLCD.h
    ../I2C/: I2C.cpp I2C.h
    ../Nokia SPI/: Nokia.cpp Nokia.h
    ../Sensor GY-271/: GY-271.cpp GY-271.h
    ../Sensor MBE280/: MBE280.cpp MBE280.h
    ../Timers HC-SR04/: HCSR04.cpp HCSR04.h
    ../Usart2/: Usart2.cpp Usart2.h
software components: CMSIS:CORE 5.6.0, CMSIS:DSP 1.10.0, Device:Startup 2.6.3
